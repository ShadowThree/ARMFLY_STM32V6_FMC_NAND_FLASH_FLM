# Keil uVision project ARMFLY_STM32V6_FLM.uvprojx, settings and files
target STM32F4xx_128 (6180000::V6.18::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: STM32V6_NAND_FLASH
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=5
  c define: FLASH_MEM,STM32F429xx
  c include: .\..;.\FMC
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group FMC
    ./FMC/: stm32f4_fmc.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_nand.c system_stm32f4xx.c stm32f4xx_hal_rcc.c stm32f4xx_ll_fmc.c
target STM32F4xx_256 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: STM32F4xx_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F4xx_256
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_384 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F4xx_384
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F4xx_384
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_512 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F4xx_512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F4xx_512
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_1024 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F4xx_1024
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F4xx_1024
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_1024dual (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F4xx_1024dual
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F4xx_1024dual
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_2048 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F4xx_2048
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F4xx_2048
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F401xx_OPT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F401xx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_OPT STM32F401xx
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F411xx_OPT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F411xx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_OPT STM32F411xx
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F40xxx_41xxx_OPT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F40xxx_41xxx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_OPT STM32F40xxx_41xxx
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F42xxx_43xxx_OPT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F42xxx_43xxx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_OPT STM32F42xxx_43xxx
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F410xx_412xx_OPT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F410xx_412xx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_OPT STM32F410xx_412xx
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F413xx_423xx_OPT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F413xx_423xx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_OPT STM32F413xx_423xx
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F446xx_OPT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F446xx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_OPT STM32F446xx
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F469xx_479xx_OPT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F469xx_479xx_OPT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_OPT STM32F469xx_479xx
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_OTP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F4xx_OTP
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_OTP
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32F4xx_1536 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: as above
  output: STM32F4xx_1536
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM STM32F4xx_1536
  c include: .\..
  asm include: .\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
